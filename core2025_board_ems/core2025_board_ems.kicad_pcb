# Repository team-continue/core2025_boards

## KiCad design core2025_board_ems/core2025_board_ems.kicad_pcb

Parts:
C1: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2: MA10EB045; Vishay_SMPA
F1: Fuse; Fuse_Holder
J1: OUT1; AMASS_XT60-F_1x02_P7.20mm_Vertical
J2: OUT2; AMASS_XT60-F_1x02_P7.20mm_Vertical
J3: OUT3; AMASS_XT60-F_1x02_P7.20mm_Vertical
J4: SIG; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5: EMERGENCY; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J11: POWER IN; AMASS_XT60-M_1x02_P7.20mm_Vertical
J12: POWER IN; BarrelJack_Horizontal
Q1: TJ60S04M3L; TO-252-3_TabPin2
Q2: BSS138; SOT-23
R1, R2, R4: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 75; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R5: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: NJM78L12S; SOT-89-3_Handsoldering
U2: TLP291; SSOP-4_4.4x2.6mm_P1.27mm

Connections:
GND: J4.1, R5.2
GNDPWR: C2.2, C3.2, J1.1, J2.1, J3.1, J12.2, Q2.2 (S), R4.2, U1.2 (GND)
unnamed: D1.2 (A), J11.2
unnamed: D1.1 (K), D2.1 (K), F1.1
unnamed: D2.2 (A), J12.1
unnamed: J1.2, J2.2, J3.2, Q1.2 (D)
unnamed: J4.2, U2.1
unnamed: J5.1, U2.4
unnamed: C3.1, J5.2, U1.1 (VO)
unnamed: J11.1, J12.3
unnamed: C1.2, Q1.1 (G), R1.2, R2.1
unnamed: C1.1, C2.1, F1.2, Q1.3 (S), R1.1, U1.3 (VI)
unnamed: Q2.3 (D), R2.2
unnamed: Q2.1 (G), R3.2, R4.1
unnamed: R3.1, U2.3
unnamed: R5.1, U2.2

Board: 2 copper layers, 70.0 x 40.0 mm, 22 parts (13 on the bottom side), 16 nets.

## KiCad design KiCadProject/CoRE2025MainBoard_1/CoRE2025MainBoard_1.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C11: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8, C9: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10, C12, C13: 1000u/35V; CP_Radial_D12.5mm_P5.00mm
D1, D2, D3: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: 5A; Fuseholder_Blade_Mini_Keystone_3568
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965
J1: ICM-20948
J2: I2C; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: LvConv; DIP-12_W10.16mm_LongPads
J4: EmergencySW; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5: Emergency; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J6, J7: UART; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J8: XT60M; AMASS_XT60-M_1x02_P7.20mm_Vertical
J9: XH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J10: VH; JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical
J11, J12: RJ45; RJ45_Ninigi_GE
J13, J16: XH; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J14, J15: PH; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
Q1: INKA114AS1; TO-92L_Inline_Wide
Q2: 2SA1015; TO-92_Inline
R1: NC; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 7.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R9, R11: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R8: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R7: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW1; SW_Push_1P1T_NO_6x6mm_H9.5mm
SW2, SW3: SW_SPST; SS12D01G4
U1: Teensy4.1; Teensy41
U2: cc6_xxxxxF-E
U3: DCL541A01; SOIC-16W_7.5x10.3mm_P1.27mm
U4, U5: ISO1044BD; SOIC-8_3.9x4.9mm_P1.27mm
U6: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm
U7: MPD7K020S

Connections:
+3V3: C2.1, C3.1, C4.1, J1.2, J2.2, J3.9, U1.15 (3V3), U1.46 (3V3), U3.1 (VDD1), U4.1 (VCC1), U5.1 (VCC1)
+5V: C1.1, J3.4, J4.2, U1.48 (VIN), U2.7 (+Vout)
+5VP: C5.1, C6.1, C7.1, C8.1, C9.1, C11.1, C12.1, C13.1, J13.2, Q2.1 (E), R6.1, R10.1, U3.16 (VDD2), U4.8 (VCC2), U5.8 (VCC2), U6.8 (VCC), U7.6 (OUT)
+9V: J10.2, J14.2, J15.2, R9.1
+24V: C10.1, F1.2, J9.2, J16.2, R11.1, U2.1 (+Vin), U7.1 (VIN)
/CAN2_H: J12.1, R8.1, U5.6 (CANH)
/CAN2_L: J12.2, R8.2, U5.5 (CANL)
/CAN2_RX: U1.2 (0_RX1_CRX2_CS1), U5.3 (RXD)
/CAN2_TX: U1.3 (1_TX1_CTX2_MISO1), U5.2 (TXD)
/Client_UART_RX1: J3.11, U1.38 (16_A2_RX4_SCL1)
/Client_UART_RX2: J3.2, J6.4
/Client_UART_TX1: J3.12, U1.39 (17_A3_TX4_SDA1)
/Client_UART_TX2: J3.1, J6.3
/Destroy1: J3.8, U1.37 (15_A1_RX3_SPDIF_IN)
/Destroy2: J3.5, J5.3
/ESC_PWM_IN: U1.14 (12_MISO_MQSL), U3.4 (VIB)
/ESC_PWM_OUT: J16.3, U3.13 (VOB)
/FDCAN1_H: J11.1, R5.1, U4.6 (CANH)
/FDCAN1_L: J11.2, R5.2, U4.5 (CANL)
/FDCAN1_RX: U1.22 (30_CRX3), U4.3 (RXD)
/FDCAN1_TX: U1.23 (31_CTX3), U4.2 (TXD)
/I2C_SCL: J2.3, U1.41 (19_A5_SCL)
/I2C_SDA: J2.4, U1.40 (18_A4_SDA)
/LED_PWM_IN: U1.16 (24_A10_TX6_SCL2), U3.3 (VIA)
/LED_PWM_OUT: J13.3, U3.14 (VOA)
/MAIN_3Rx: J7.3, U1.43 (21_A7_RX5_BCLK1)
/MAIN_3Tx: J7.2, U1.42 (20_A6_TX5_LRCLK1)
/MAIN_TEST: J7.4, U1.44 (22_A8_CTX1)
/PWR_EN: Q1.1 (G), U1.32 (40_A16)
/SPI_CS: J1.6, U1.30 (38_CS1_IN1)
/SPI_MISO: J1.5, U1.31 (39_MISO1_OUT1A)
/SPI_MOSI: J1.3, U1.18 (26_A12_MOSI1)
/SPI_SCK: J1.4, U1.19 (27_A13_SCK1)
/SW1: SW1.1, U1.45 (23_A9_CRX1_MCLK1)
/UART_RX_IN: U1.9 (7_RX2_OUT1A), U3.6 (VOD)
/UART_RX_OUT: U3.11 (VID), U6.1 (RO)
/UART_TTL: J14.3, J15.3, U6.6 (A)
/UART_TX_IN: U1.10 (8_TX2_IN1), U3.5 (VIC)
/UART_TX_OUT: R2.1, U3.12 (VOC), U6.4 (DI)
GND: C1.2, C2.2, C3.2, C4.2, J1.1, J2.1, J3.3, J3.10, J5.1, J6.1, J7.1, Q1.3 (S), R1.2, SW1.2, U1.1 (GND), U1.34 (GND), U1.47 (GND), U2.5 (-Vout), U3.2 (GND1), U3.7 (DIS1), U3.8 (GND1), U4.4 (GND1), U5.4 (GND1)
GNDPWR: C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, D1.1 (K), D2.1 (K), D3.1 (K), J8.1, J9.1, J10.1, J13.1, J14.1, J15.1, J16.1, R4.2, R7.2, SW2.2 (B), SW3.1 (A), U2.3 (-Vin), U3.9 (GND2), U3.10 (DIS2), U3.15 (GND2), U4.7 (GND2), U5.7 (GND2), U6.5 (GND), U7.3 (GND)
unnamed: D1.2 (A), R9.2
unnamed: D2.2 (A), R10.2
unnamed: D3.2 (A), R11.2
unnamed: J4.1, Q1.2 (D)
unnamed: F1.1, J8.2
unnamed: Q2.3 (B), R2.2
unnamed: Q2.2 (C), R3.1, U6.2 (~RE), U6.3 (DE)
unnamed: R3.2, R4.1
unnamed: SW2.1 (A), U2.2 (RC)
unnamed: SW3.2 (B), U7.5 (VAR)
unnamed: R1.1, U2.6 (TRM)
unnamed: R6.2, R7.1, U6.7 (B)

Notes on the sheet:
TTL
メインボードよりコマンド入力 （５V ロジック）
ESC
ClientModule
コマンド入力 Rx
機体のメインボード、コントロー ラのユーザ CPU と接続
DCDC 24V -> 5V
CAN
VDD
Isolate
CPU
LED_PWM
メインボードへステータス出力
無線モジュール
Tx/Rxは貸出基板が主体
ステータス出力 Tx

Board: 2 copper layers, 100.0 x 100.0 mm, 60 parts (0 on the bottom side), 53 nets.

## KiCad design KiCadProject/CANExpander_1/CANExpander_1.kicad_pcb

Parts:
C1, C2, C3: 390u/35V; CP_Radial_D10.0mm_P5.00mm
D1: SMAJ26A; D_SMA
D2: Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: Car Small Fuse; Fuseholder_Blade_Mini_Keystone_3568
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965
J1, J2, J3, J4: XT30(2+2)-M; CONN-TH_XT30PB-M
J5: XT60-M; AMASS_XT60-M_1x02_P7.20mm_Vertical
J6, J7: RJ45-10-V02P; RJ45_Ninigi_GE
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+24V: C1.1, C2.1, C3.1, D1.1 (A1), D2.1 (K), F1.2, J1.4, J2.4, J3.4, J4.4
/CAN_H: J1.2, J2.2, J3.2, J4.2, J6.1, J7.1
/CAN_L: J1.1, J2.1, J3.1, J4.1, J6.2, J7.2
GND: C1.2, C2.2, C3.2, D1.2 (A2), J1.3, J2.3, J3.3, J4.3, J5.1
unnamed: D2.2 (A), R1.2
unnamed: F1.1, J5.2, R1.1

Board: 2 copper layers, 70.0 x 40.0 mm, 18 parts (1 on the bottom side), 6 nets.

## Commit log

2025-02-10 射出用MDの基板データとユーザー製作ライブラリ
    使ってるCADが違うから一応フォルダ分けといた
2025-05-09 BLMDのりーどみいをまとめたよ
2025-05-31 Add core2025_board_ems schematic, Fuse_Holder footprint, and library table
    - Added core2025_board_ems.pdf schematic file for the board design.
    - Created Fuse_Holder.kicad_mod footprint for the fuse holder component.
    - Introduced fp-lib-table to include the new footprint library in the project.
