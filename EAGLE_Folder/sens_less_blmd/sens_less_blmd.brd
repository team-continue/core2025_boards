# Repository team-continue/core2025_boards

## EAGLE design EAGLE_Folder/sens_less_blmd/sens_less_blmd.brd

File EAGLE_Folder/sens_less_blmd/README.md:

# センサレスブラシレスモータドライバの基板
FETドライブ基板、MCU基板を基板対基板コネクタでつなげることでモータシステムを構成している。
この構成の利点としては、故障の可能性が高いFETドライブ基板を切り離すことで運用コストの低下、高さ方向に基板をつなげることで下方占有面積の削減を目的としている。
特に、ヒートシンクや電源コネクタ等を基板に搭載すると高さ方向にデッドスペースが多く発生するためその有効利用となる。

## FETドライブ基板サイズ
58.5 x 78.4

## 取付穴ピッチ
52.5 x 49 M3

## 対応ヒートシンク
ヒートシンクの取り付けを前提とした設計をしており優れた放熱効果を実現する。
* ALPHA DCC5923Lシリーズ

## MCU基板インターフェース
* CAN通信用コネクタは2種類基板上に搭載しており、用途に応じて柔軟に対応可能としている。特にRJ45コネクタではCAN以外に12V電源ラインを有しておりLANケーブルのみでの通信電源確保を可能としている。<br>
* 過去にMDを設計した際、組み込みで使うIFのみしか用意しなかった結果ファームウェアの開発が非常にめんどくさくなったため、ロボット組み込み時は使わないがデバッグ用のUARTを装備している。<br>
* UART用の5ピンコネクタには、USB-UART変換によくついている5V電源を入力するピンがあり、5V出力を有するUSB-UART変換であればこれ単体でMCUの起動が可能である。<br>
* MCU基板単体でのデバッグ作業が可能なように電源入力用のコネクタを用意している。さらにFETドライブ基板側にも電源出力があり、GNDラインの絶縁を犠牲にすることでMCU側への電源供給が可能<br>
* MCU基板は5V系IC、3.3V系ICの2系が存在し、5V生成にスイッチング電源を利用し、電源入力を高電圧としバスの電流負荷を軽減することを狙っている。<br>

### 通信ライン
CAN,UART<br>
### 電源
PowerSupply 12V

### RJ45 ピンアサイン
POEのピンアサインに似せている
|Pin num|Function|
|---|---|
|1||
|2||
|3|CANL|
|4|Power_Supply|
|5|Power_Supply|
|6|CANH|
|7|GND|
|8|GND|

## MCUぺりふぇらるあさいん
|Pin num|Pin name|peripheral|note|
|----|----|----|----|
|1|RA7|GPIO IN|CAN ID1|
|2|RB14|NONE||
|3|RB15|QEICMP1|Unsupported|
|4|MCLR|||
|5|VSS|||
|6|VDD|||
|7|RA12|NONE||
|8|RA11|NONE||
|9|RA0|AN0|ADC W_CURRENT|
|10|RA1|NONE||
|11|RB0|AN2|ADC U_CURRENT|
|12|RB1|NONE||
|13|RB2|PGC1||
|14|RB3|PGD1||
|15|AVDD|||
|16|AVSS|||
|17|RC0|QEA1|Unsupported|
|18|RC1|INDX1|Unsupported|
|19|RC2|HOME1|Unsupported|
|20|RC11|NONE||
|21|VSS|||
|22|VDD|||
|23|RA8|QEB1|Unsupported|
|24|RB4|C1TX|CAN_TX|
|25|RA4|C1RX|CAN_RX|
|26|VDD|||
|27|RC12|OSCI||
|28|RC15|OSCO||
|29|VSS|||
|30|RD8|GPIO IN|MD_FAULT|
|31|RB5|GPIO OUT|STAT_LED|
|32|RB6|U1RX|UART_RX|
|33|RC10|NONE||
|34|RB7|U1TX|UART_TX|
|35|RC13|GPIO OUT|FF1_LED(bord err "only input")|
|36|RB8|GPIO OUT|FF2_LED(bord err "only input")|
|37|RB9|NONE||
|38|RC6|PWM6H|MCPWM AHI|
|39|RC7|PWM6L|MCPWM ALO|
|40|RC8|PWM5H|MCPWM BHI|
|41|RC9|PWM5L|MCPWM BLO|
|42|VSS|||
|43|VDD|||
|44|RB10|PWM3H|MCPWM CHI|
|45|RB11|PWM3L|MCPWM CLO|
|46|RB12|GPIO IN|CAN ID4|
|47|RB13|GPIO IN|CAN ID3|
|48|RA10|GPIO IN|CAN ID2|

* VSS IS GND,VDD IS POWER SUPPLY(3.3V),"NONE" MUST BE "INTERNAL PULLUP" OR "GPIO OUT"

## ファームウェアについて
### マイコンについて
MCUにはPIC32MK0512MCJ048を採用しており、32BitPICのなかモータ制御向けとして販売されているものである。<br>
特徴として、専用の直行エンコーダインターフェース(QEI)、モータ制御用PWM(MCPWM)、CANFDが搭載されている。<br>
今回は利用していないがQEIはカウンタパルスのほかにカウンタパルス間の測定も可能となっており、高速域、低速域の領域でエンコーダを有効に利用できるペリフェラルである。<br>
さらに、前回のカウンタリード値と現在のカウンタリード値の差分を記憶するレジスタもあり速度計算も非常に用意に実装可能である。<br>
**QEI便利だね**<br>
モータ制御用PWMではPWMのカウンタマッチ割り込みがあり、これをADCの変換フラグに利用することが可能である。<br>
つまり、センターアラインPWMを利用すればPWM波形の一番安定した場所でADCのデータをペリフェラルのみで取得可能であるということだ。<br>
**これは本当に便利**<br>
トリガポイントはさらに柔軟に設定可能なので、割り込みハンドラを処理するときにはすでに変換データが容易されている状態を作り出すことすら可能である。<br>

### 制御について
6パルスIPDを実装し、磁器突極性を問わず初期位置推定を可能としている。<br>
IPDによって、初期位置を検出し任意の進角で動作を開始し、オープンループで十分なBEMFを取得できる速度域まで動作させる。（ここまではできた）<br>
そこから、FOCに遷移する。予定だった。ort

## コメント
いろいろ能書き書いたけどファーム未完成<br>
現代制御なんもわからん

Parts:
C1, C2, C3, C4, C5, C6, C7, C14, C15: 0.1u; C1608
C8, C9, C17: SNB; C4532
C10: 1u; C1608
C11, C12, C13: 0.22u; C1608
C16: 10u; C1608
C23: 47u; 153CLV-0605
CON1, CON2: XH_8P
CPOL1, CPOL2: 330u; 1014CAPA
D1: RB160M-30TR; SOD_123
D2, D3, D4, D5, D6, D7: SBR15U30SP5; POWERDI_5
D8: SMAJ22A-13-F; DO-214AC
IC1: A4919; TSSOP_28P_ALLEGRO_E
K1, K2, K3: TLP2105; SOP8
K4: TLP291
LED1: RGB_LED
Q1, Q2, Q3: IAUC60N04S6L045HATMA1PG-TDSON-8-57; PG-TDSON-8-57
Q4, Q5: AO3400A; SOT23
R1, R2, R3, R4, R5, R6: 10; 1608
R7, R8, R9, R10, R11, R12, R18, R31: 47k; 1608
R13, R14, R15, R16, R17, R19, R20, R22, R23, R24, R25, R26, R27, R28, R32, R33, R34: R_REG; 1608
R21: 0; 1608
R29: 3.3k; 1608
R30: optional; 1608
R35: OP; 1608
U1, U2: ACS711; SOIC8
U$1: XH_2P
U$2: DCC5923L
U$22: XT60

Connections:
AHI: IC1.PIN23 (PIN23_AHI), K1.PIN6 (PIN6_VO2), R22.2
ALO: IC1.PIN24 (PIN24_ALO), K1.PIN7 (PIN7_VO1), R20.2
BHI: IC1.PIN25 (PIN25_BHI), K2.PIN6 (PIN6_VO2), R19.2
BLO: IC1.PIN26 (PIN26_BLO), K2.PIN7 (PIN7_VO1), R15.2
CHI: IC1.PIN27 (PIN27_CHI), K3.PIN6 (PIN6_VO2), R14.2
CLO: IC1.PIN28 (PIN28_CLO), K3.PIN7 (PIN7_VO1), R13.2
FAULT: IC1.PIN22 (PIN22_FAULT), Q4.PIN1 (PIN1_G), Q5.PIN1 (PIN1_G), R18.1, R30.2, R35.2
GHA: IC1.PIN11 (PIN11_GHA), R1.1
GHB: IC1.PIN7 (PIN7_GHB), R3.1
GHC: IC1.PIN3 (PIN3_GHC), R5.1
GLA: IC1.PIN10 (PIN10_GLA), R2.1
GLB: IC1.PIN6 (PIN6_GLB), R4.1
GLC: IC1.PIN2 (PIN2_GLC), R6.1
GND: C1.2, C7.2, C8.2, C9.2, C17.2, CPOL1.-, CPOL2.-, D3.1 (A1), D3.2 (A2), D5.1 (A1), D5.2 (A2), D7.1 (A1), D7.2 (A2), D8.A, IC1.PIN1 (PIN1_LSS), Q1.5 (GND_2), Q1.6 (GND), Q1.SPAD (GND_2), Q1.SPAD@1 (GND_2), Q2.5 (GND_2), Q2.6 (GND), Q2.SPAD (GND_2), Q2.SPAD@1 (GND_2), Q3.5 (GND_2), Q3.6 (GND), Q3.SPAD (GND_2), Q3.SPAD@1 (GND_2), R10.1, R11.1, R12.1, R21.2, U$1.P$2 (PIN2), U$22.-
GNDA: C2.2, C3.2, C4.2, C14.2, C15.2, C16.2, C23.-, IC1.PAD, IC1.PAD@14 (PAD), IC1.PIN19 (PIN19_GND), K1.PIN5 (PIN5_GND), K2.PIN5 (PIN5_GND), K3.PIN5 (PIN5_GND), LED1.G_K, Q4.PIN2 (PIN3_S), Q5.PIN2 (PIN3_S), R13.1, R14.1, R15.1, R17.1, R19.1, R20.1, R21.1, R22.1, R30.1, R35.1
GNDIO: CON1.P$3 (PIN3), CON2.P$7 (PIN7), CON2.P$8 (PIN8), K1.PIN2 (PIN2_KSODE1), K1.PIN3 (PIN3_KSODE2), K2.PIN2 (PIN2_KSODE1), K2.PIN3 (PIN3_KSODE2), K3.PIN2 (PIN2_KSODE1), K3.PIN3 (PIN3_KSODE2), LED1.B_K, R31.1
MCU_AHI: CON2.P$2 (PIN2), R24.1
MCU_ALO: CON2.P$1 (PIN1), R23.1
MCU_BHI: CON2.P$4 (PIN4), R26.1
MCU_BLO: CON2.P$3 (PIN3), R25.1
MCU_CHI: CON2.P$6 (PIN6), R28.1
MCU_CLO: CON2.P$5 (PIN5), R27.1
MCU_FAULT: CON1.P$2 (PIN2), K4.PIN3 (3_E), R31.2
MCU_POWER: CON1.P$1 (PIN1), K4.PIN4 (4_C), R34.1
unnamed: Q1.1 (G_2), R1.2, R7.2
unnamed: Q1.4 (G), R2.2, R12.2
unnamed: Q2.4 (G), R4.2, R10.2
unnamed: LED1.B_A, R34.2
unnamed: Q3.1 (G_2), R5.2, R8.2
unnamed: Q3.4 (G), R6.2, R11.2
unnamed: C10.1, IC1.PIN16 (PIN16_CP1)
unnamed: C10.2, IC1.PIN15 (PIN15_CP2)
unnamed: C14.1, C23.+, IC1.PIN14 (PIN14_VREG)
unnamed: K1.PIN1 (PIN1_ANODE1), R23.2
unnamed: K1.PIN4 (PIN4_ANODE2), R24.2
unnamed: K2.PIN1 (PIN1_ANODE1), R25.2
unnamed: K2.PIN4 (PIN4_ANODE2), R26.2
unnamed: K3.PIN1 (PIN1_ANODE1), R27.2
unnamed: C13.2, IC1.PIN13 (PIN13_CA)
unnamed: C12.2, IC1.PIN9 (PIN9_CB)
unnamed: C11.2, IC1.PIN5 (PIN5_CC)
unnamed: K3.PIN4 (PIN4_ANODE2), R28.2
unnamed: K4.PIN2 (2_K), Q4.PIN3 (PIN2_D)
unnamed: C15.1, D1.K (C), IC1.PIN17 (PIN17_VBB)
unnamed: K4.PIN1 (1_A), R29.2
unnamed: Q2.1 (G_2), R3.2, R9.2
unnamed: LED1.G_A, R33.2
unnamed: LED1.R_A, R32.2
unnamed: LED1.R_K, Q5.PIN3 (PIN2_D)
PHASE_U: C13.1, D2.1 (A1), D2.2 (A2), D3.3 (K), IC1.PIN12 (PIN12_SA), Q1.2 (PHASE_2), Q1.3 (PHASE), Q1.SDPAD (PHASE_2), Q1.SDPAD@1 (PHASE_2), Q1.SDPAD@2 (PHASE_2), R7.1, U1.P$1 (1_IP+), U1.P$2 (2_IP+)
PHASE_U_OUT: U1.P$3 (3_IP-), U1.P$4 (4_IP-)
PHASE_V: C12.1, D4.1 (A1), D4.2 (A2), D5.3 (K), IC1.PIN8 (PIN8_SB), Q2.2 (PHASE_2), Q2.3 (PHASE), Q2.SDPAD (PHASE_2), Q2.SDPAD@1 (PHASE_2), Q2.SDPAD@2 (PHASE_2), R9.1
PHASE_W: C11.1, D6.1 (A1), D6.2 (A2), D7.3 (K), IC1.PIN4 (PIN4_SC), Q3.2 (PHASE_2), Q3.3 (PHASE), Q3.SDPAD (PHASE_2), Q3.SDPAD@1 (PHASE_2), Q3.SDPAD@2 (PHASE_2), R8.1, U2.P$1 (1_IP+), U2.P$2 (2_IP+)
PHASE_W_OUT: U2.P$3 (3_IP-), U2.P$4 (4_IP-)
U_CURRENT: CON1.P$6 (PIN6), U1.P$7 (7_VIOUT)
V5: C2.1, C3.1, C4.1, C16.1, IC1.PIN20 (PIN20_V3,V5,VDDM), K1.PIN8 (PIN8_VCC), K2.PIN8 (PIN8_VCC), K3.PIN8 (PIN8_VCC), R16.2, R18.2, R29.1, R32.1, R33.1
VCC: C1.1, C7.1, C8.1, C9.1, C17.1, CPOL1.+, CPOL2.+, D1.A, D2.3 (K), D4.3 (K), D6.3 (K), D8.C, IC1.PIN18 (PIN18_VBRG), Q1.7 (BATTERY_2), Q1.8 (BATTERY), Q1.DPAD (BATTERY_2), Q1.DPAD@1 (BATTERY_2), Q2.7 (BATTERY_2), Q2.8 (BATTERY), Q2.DPAD (BATTERY_2), Q2.DPAD@1 (BATTERY_2), Q3.7 (BATTERY_2), Q3.8 (BATTERY), Q3.DPAD (BATTERY_2), Q3.DPAD@1 (BATTERY_2), U$1.P$1 (PIN1), U$22.+
VDSTH: IC1.PIN21 (PIN21_VDSTH), R16.1, R17.2
VREF+: C5.1, C6.1, CON1.P$4 (PIN4), U1.P$8 (8_VCC), U2.P$8 (8_VCC)
VREF-: C5.2, C6.2, CON1.P$5 (PIN5), CON1.P$7 (PIN7), U1.P$5 (5_GND), U2.P$5 (5_GND)
W_CURRENT: CON1.P$8 (PIN8), U2.P$7 (7_VIOUT)

Notes on the sheet:
三相フルブリッジ回路部
A4919GLPTR-5-T
LDO output 5V
PullDown47k
typically 1k ohm must check MCU output current
If self-turn on, add a resistor
Isolation Interface
MotorControlGateDriver
V_{dsth} Range between 0.2 to 2 [V]
At R_{ds(on)} = 6 mohm
V_{dsth}= R_{2}*(Vcc-R_{1}*I_{L})/(R_{2}+R_{1})
V_{dsth} = 0.34
FaultCurrent 57 A
R16 = 47k,R17 = 3.3k
Conector
SNB Capacitor is optional please use LowESR LowESL FilmCapacitor typicaliy [63MU105KC24532]
25PFV330M10X10.5
35PFV47M6.3X6.1
Available ct417 and ct416

Board: 2 copper layers, 78.4 x 58.5 mm, 81 parts (33 on the bottom side), 61 nets.

## EAGLE design EAGLE_Folder/sens_less_blmd/BLMD_MCU/BLMD_MCU.brd

Parts:
C1, C2, C4, C5, C12: 0.1u; C1608
C3: C-EUC1608; C1608
C6: 100u; C3216
C7: 10u; C1608
C8, C9, C11: 1u; C1608
C10: 2.2u; C1608
CN1: 7810-8P8C; 78108P8C
CON1, CON2: JQ_S8P
CON3: XH_4P
CON4: XH_6P
CON5: XH_3P
D1, D2, D3: SBR2U30P1; SOD_123
IC1: ADP151AUJZ; SOT23-5
IC2: NJM1616T; SOT23-6
IC3: AZ1117CH; SOT223-W
IC4: MCP2562MCP2561-SN; SOIC8
JP1: PINHD-1X2; 1X02
L1: 47u; SMD_INDUCTOR
LED1: RGB_LED
OSC1: 20MHz; CSTNE#
R1, R6: 10k; 1608
R2, R3, R4, R5, R10, R11, R12, R16, R17, R18: R_REG; 1608
R7: 3.3k; 1608
R8: 0; 1608
R9: 120; 1608
R13, R14, R15: 47k; 1608
SW1: DIPSW4
U$1: PIC32MK0512MCJ048; LQFP48PIN
U$2: TVAF06-A020B-R; TAKUTOSUITTI2
U$4: XH_2P
U$5: CUHS20S30; SOD323-W
U$6: FDC6305; SSOT6
U$7: AO3400A; SOT23

Connections:
+5V: C6.1, C8.1, C11.1, C12.1, D1.K (C), IC1.1 (1_VIN), IC1.3 (3_EN), IC3.3 (PIN3_INPUT), IC4.P$3 (VDD), L1.P$2 (2), R6.2
AGND: C8.2, C9.2, CON2.P$5 (PIN5), CON2.P$7 (PIN7), IC1.2 (2_GND), R8.2, R10.1, R11.1, R12.1, U$1.PIN16 (PIN16_AVSS)
AHI: CON1.P$2 (PIN2), U$1.PIN38 (PIN38_RC6)
ALO: CON1.P$1 (PIN1), U$1.PIN39 (PIN39_RC7)
AVCC: C9.1, CON2.P$4 (PIN4), IC1.5 (5_VOUT), U$1.PIN15 (PIN15_AVDD)
BHI: CON1.P$4 (PIN4), U$1.PIN40 (PIN40_RC8)
BLO: CON1.P$3 (PIN3), U$1.PIN41 (PIN41_RC9)
CANH: CN1.6, CON5.P$1 (PIN1), IC4.P$7 (CANH), JP1.1
CANL: CN1.3, CON5.P$2 (PIN2), IC4.P$6 (CANL), R9.1
CAN_RX: IC4.P$4 (RXD), U$1.PIN25 (PIN25_RA4)
CAN_TX: IC4.P$1 (TXD), U$1.PIN24 (PIN24_RB4)
CHI: CON1.P$6 (PIN6), U$1.PIN44 (PIN44_RB10)
CLO: CON1.P$5 (PIN5), U$1.PIN45 (PIN45_RB11)
FF1_LED: R14.1, U$1.PIN35 (PIN35_SOSCI_RC13), U$6.1 (PIN1_G1)
FF2_LED: R15.1, U$1.PIN36 (PIN36_SOSCO_RB8), U$6.3 (PIN3_G2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C10.2, C11.2, C12.2, CN1.7, CN1.8, CON1.P$7 (PIN7), CON1.P$8 (PIN8), CON2.P$3 (PIN3), CON3.P$4 (PIN4), CON4.P$3 (PIN3), CON5.P$3 (PIN3), IC2.2 (2_GND), IC3.1 (PIN1_GND), IC4.P$2 (VSS), IC4.P$8 (STBY), OSC1.P$2 (GND), R2.1, R3.1, R4.1, R5.1, R7.1, R8.1, R13.1, R14.2, R15.2, U$1.PIN5 (PIN5_VSS), U$1.PIN21 (PIN21_VSS), U$1.PIN29 (PIN29_VSS), U$1.PIN42 (PIN42_VSS), U$2.P$2 (PIN2), U$4.P$2 (PIN2), U$5.A, U$7.PIN2 (PIN3_S)
HOME1: U$1.PIN19 (PIN19_RC2)
ID_1: R2.2, SW1.P$1 (1), U$1.PIN1 (PIN1_RA7)
ID_2: R3.2, SW1.P$2 (2), U$1.PIN48 (PIN48_RA10)
ID_3: R4.2, SW1.P$3 (3), U$1.PIN47 (PIN47_RB13)
ID_4: R5.2, SW1.P$4 (4), U$1.PIN46 (PIN46_RB12)
INDX1: U$1.PIN18 (PIN18_RC1)
MCLR: C1.1, CON4.P$1 (PIN1), R1.1, U$1.PIN4 (PIN4_MCLR), U$2.P$1 (PIN1)
MD_FAULT: CON2.P$2 (PIN2), U$1.PIN30 (PIN30_RD8)
unnamed: R12.2, U$1.PIN8 (PIN8_RA11)
unnamed: R11.2, U$1.PIN10 (PIN10_RA1)
unnamed: LED1.B_A, R18.2
unnamed: R10.2, U$1.PIN12 (PIN12_PGC3_VREF+_RB1)
unnamed: OSC1.P$3 (OUT), U$1.PIN27 (PIN27_OSCI_RC12)
unnamed: OSC1.P$1 (IN), U$1.PIN28 (PIN28_OSCO_RC15)
unnamed: LED1.G_A, R17.2
unnamed: JP1.2, R9.2
unnamed: IC2.6 (6_SW), L1.P$1 (1), U$5.C
unnamed: IC2.3 (3_FB), R6.1, R7.2
unnamed: LED1.R_A, R16.2
unnamed: LED1.B_K, U$7.PIN3 (PIN2_D)
unnamed: CON3.P$1 (PIN1), D1.A
unnamed: LED1.G_K, U$6.6 (PIN6_D1)
unnamed: LED1.R_K, U$6.4 (PIN4_D2)
unnamed: D2.A, U$4.P$1 (PIN1)
unnamed: CN1.4, CN1.5, D3.A
PGC: CON4.P$5 (PIN5), U$1.PIN13 (PIN13_PGC1_RB2)
PGD: CON4.P$4 (PIN4), U$1.PIN14 (PIN14_PGD1_RB3)
QEA1: U$1.PIN17 (PIN17_RC0)
QEB1: U$1.PIN23 (PIN23_RA8)
QEICMP1: U$1.PIN3 (PIN3_RB15)
STAT_LED: R13.2, U$1.PIN31 (PIN31_PGD2_RB5), U$7.PIN1 (PIN1_G)
UART_RX: CON3.P$2 (PIN2), U$1.PIN32 (PIN32_PGC2_RB6)
UART_TX: CON3.P$3 (PIN3), U$1.PIN34 (PIN34_RB7)
U_CURRENT: CON2.P$6 (PIN6), U$1.PIN11 (PIN11_PGD3_VREF-_RB0)
V+: C7.1, D2.K (C), D3.K (C), IC2.4 (4_SHDN), IC2.5 (5_VIN)
VCC: C2.1, C3.1, C4.1, C5.1, C10.1, CON2.P$1 (PIN1), CON4.P$2 (PIN2), IC3.2 (PIN2_OUT), IC3.4 (PIN4_OUT), IC4.P$5 (VIO), R1.2, R16.1, R17.1, R18.1, SW1.P$5 (5), SW1.P$6 (6), SW1.P$7 (7), SW1.P$8 (8), U$1.PIN6 (PIN6_VDD), U$1.PIN22 (PIN22_VDD), U$1.PIN26 (PIN26_VDD), U$1.PIN43 (PIN43_VDD)
W_CURRENT: CON2.P$8 (PIN8), U$1.PIN9 (PIN9_RA0)

Notes on the sheet:
Shield to Anarog Signal Input
未実装
47k ohom
1k ohom
MCPWM
CAN ID Configration
MD Interface
UART Interface at 3.3V
MCU Debug Interface
Special Power Supply
Special CAN Interface
Standard CAN And Power Interface
Analog Power Supply
MCU Power Supply
Down Converter
LED for Stat And FF
ID Select DipSW
Reset Circuit
CAN Tra

Board: 2 copper layers, 40.0 x 58.5 mm, 54 parts (21 on the bottom side), 48 nets.

## Commit log

2025-02-10 射出用MDの基板データとユーザー製作ライブラリ
    使ってるCADが違うから一応フォルダ分けといた
2025-05-09 BLMDのりーどみいをまとめたよ
2025-05-31 Add core2025_board_ems schematic, Fuse_Holder footprint, and library table
    - Added core2025_board_ems.pdf schematic file for the board design.
    - Created Fuse_Holder.kicad_mod footprint for the fuse holder component.
    - Introduced fp-lib-table to include the new footprint library in the project.

Notices in the files:
parts and their libraries:
COPYRIGHT: Copyright (C) 2024 Ultra Librarian. All rights reserved.
